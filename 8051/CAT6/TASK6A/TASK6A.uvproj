# Keil uVision project TASK6A.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(11059200) MODP2
  output: TASK_6A +hex
  group Source Group 1
    ./: STARTUP.A51 uart.c main.c
